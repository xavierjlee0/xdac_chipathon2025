v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 2880 -2580 3160 -2580 {}
L 4 2880 -2580 2880 -2100 {}
L 4 2880 -2100 3200 -2100 {}
L 4 3200 -2580 3200 -2100 {}
L 4 3160 -2580 3200 -2580 {}
T {INTERNAL BUS CONNECTIONS} 2885 -2130 0 0 0.4 0.4 {}
N 460 -1550 460 -1320 {lab=push_pull_out}
N 460 -1320 460 -1080 {lab=push_pull_out}
N 240 -2700 260 -2700 {lab=top_iref}
N 460 -2700 490 -2700 {lab=top_iref}
N 2120 -2750 2120 -2700 {lab=bus5_buff}
N 2140 -2450 2140 -2430 {lab=bus5_buff}
N 2140 -2430 2270 -2430 {lab=bus5_buff}
N 2270 -2710 2270 -2430 {lab=bus5_buff}
N 2120 -2720 2270 -2720 {lab=bus5_buff}
N 2270 -2720 2270 -2710 {lab=bus5_buff}
N 650 -1170 650 -1120 {lab=vdd}
N 1670 -2750 1710 -2750 {lab=vss}
N 1870 -2750 1900 -2750 {lab=vdd}
N 1880 -2710 1930 -2710 {lab=top_iref}
N 1870 -2710 1880 -2710 {lab=top_iref}
N 1790 -2600 1790 -2560 {lab=swthirteen}
N 2000 -2450 2000 -2410 {lab=vss}
N 2020 -2450 2020 -2410 {lab=vdd}
N 2040 -2450 2040 -2410 {lab=top_iref}
N 2100 -2450 2100 -2390 {lab=BUSFIVE}
N 1900 -960 1940 -960 {lab=vss}
N 1900 -980 1940 -980 {lab=vdd}
N 1900 -1000 1940 -1000 {lab=top_iref}
N 2610 -1050 2650 -1050 {lab=vss}
N 2610 -1070 2650 -1070 {lab=vdd}
N 2610 -1090 2650 -1090 {lab=top_iref}
N 1900 -1100 1920 -1100 {lab=sweleven}
N 1920 -1220 1920 -1100 {lab=sweleven}
N 1980 -1320 1980 -1060 {lab=swten}
N 1920 -1320 1920 -1220 {lab=sweleven}
N 1620 -1320 1620 -1080 {lab=swtwelve}
N 2610 -1190 2630 -1190 {lab=swfive}
N 2630 -1310 2630 -1190 {lab=swfive}
N 2610 -1150 2650 -1150 {lab=swfour}
N 2650 -1090 2690 -1090 {lab=top_iref}
N 2160 -1440 2160 -1400 {lab=vss}
N 2160 -1320 2160 -1280 {lab=vdd}
N 2160 -1440 2160 -1400 {lab=vss}
N 2160 -1320 2160 -1280 {lab=vdd}
N 2180 -1440 2180 -1400 {lab=top_iref}
N 2180 -1480 2180 -1440 {lab=top_iref}
N 2060 -1360 2100 -1360 {lab=swnine}
N 2220 -1340 2260 -1340 {lab=sweight}
N 2900 -1360 2940 -1360 {lab=swtwo}
N 2900 -1400 3040 -1400 {lab=swone}
N 2740 -1380 2780 -1380 {lab=swthree}
N 2840 -1460 2840 -1420 {lab=vss}
N 2840 -1460 2840 -1420 {lab=vss}
N 2860 -1340 2860 -1300 {lab=top_iref}
N 1470 -1640 1470 -1570 {lab=vss}
N 1450 -1640 1450 -1570 {lab=swsixteen}
N 1380 -1640 1380 -1300 {lab=swsixteen}
N 1450 -1400 1450 -1300 {lab=swfifteen}
N 1450 -1300 1450 -1170 {lab=swfifteen}
N 1380 -1300 1380 -1170 {lab=swsixteen}
N 1470 -1400 1470 -1170 {lab=swfourteen}
N 650 -960 650 -930 {lab=vss}
N 730 -1070 1250 -1070 {lab=sweighteen}
N 1250 -1170 1250 -1070 {lab=sweighteen}
N 730 -1010 1310 -1010 {lab=swseventeen}
N 1310 -1160 1310 -1010 {lab=swseventeen}
N 1310 -1170 1310 -1160 {lab=swseventeen}
N 1250 -1320 1250 -1170 {lab=sweighteen}
N 1310 -1320 1310 -1170 {lab=swseventeen}
N 2060 -1360 2060 -1300 {lab=swnine}
N 2260 -1340 2260 -1280 {lab=sweight}
N 2300 -1380 2300 -1280 {lab=swseven}
N 2740 -1380 2740 -1280 {lab=swthree}
N 2940 -1360 2940 -1280 {lab=swtwo}
N 3040 -1400 3040 -1280 {lab=swone}
N 2860 -1300 2860 -1220 {lab=top_iref}
N 2670 -1310 2670 -1150 {lab=swfour}
N 2340 -1340 2340 -1170 {lab=swsix}
N 2630 -1340 2630 -1310 {lab=swfive}
N 2670 -1340 2670 -1310 {lab=swfour}
N 2840 -1340 2840 -1310 {lab=vdd}
N 1560 -2280 1560 -1160 {lab=swthirteen}
N 1380 -1640 1450 -1640 {lab=swsixteen}
N 1620 -1080 1650 -1080 {lab=swtwelve}
N 1900 -1060 1980 -1060 {lab=swten}
N 2060 -1300 2060 -1270 {lab=swnine}
N 2650 -1150 2670 -1150 {lab=swfour}
N 2340 -1170 2360 -1170 {lab=swsix}
N 2220 -1380 2300 -1380 {lab=swseven}
N 2120 -2760 2120 -2750 {lab=bus5_buff}
N 2990 -2820 2990 -2760 {lab=swmatrix_bus[1]}
N 2990 -2760 3140 -2760 {lab=swmatrix_bus[1]}
N 2790 -2720 3140 -2720 {lab=swmatrix_bus[2]}
N 2790 -2820 2790 -2720 {lab=swmatrix_bus[2]}
N 2570 -2820 2570 -2680 {lab=swmatrix_bus[3]}
N 2570 -2680 3140 -2680 {lab=swmatrix_bus[3]}
N 2350 -2640 3140 -2640 {lab=swmatrix_bus[4]}
N 2990 -2600 3140 -2600 {lab=BUSFIVE}
N 2990 -2560 3140 -2560 {lab=swmatrix_bus[6]}
N 2990 -2520 3140 -2520 {lab=swmatrix_bus[7]}
N 2990 -2480 3140 -2480 {lab=swmatrix_bus[8]}
N 2990 -2440 3140 -2440 {lab=swmatrix_bus[9]}
N 2990 -2400 3140 -2400 {lab=swmatrix_bus[10]}
N 2990 -2360 3140 -2360 {lab=swmatrix_bus[11]}
N 2990 -2320 3140 -2320 {lab=swmatrix_bus[12]}
N 2560 -2600 2990 -2600 {lab=BUSFIVE}
N 2350 -2600 2560 -2600 {lab=BUSFIVE}
N 2350 -2600 2350 -2380 {lab=BUSFIVE}
N 2100 -2380 2350 -2380 {lab=BUSFIVE}
N 2100 -2390 2100 -2380 {lab=BUSFIVE}
N 2990 -2280 3140 -2280 {lab=swmatrix_bus[13]}
N 2990 -2240 3140 -2240 {lab=swmatrix_bus[14]}
N 2990 -2200 3140 -2200 {lab=swmatrix_bus[15]}
N 2990 -2160 3140 -2160 {lab=swmatrix_bus[16]}
N 490 -2700 600 -2700 {lab=top_iref}
N 1560 -2560 1560 -2280 {lab=swthirteen}
N 560 -1040 600 -1040 {lab=push_pull_out}
N 560 -1320 560 -1040 {lab=push_pull_out}
N 450 -1320 560 -1320 {lab=push_pull_out}
N 1560 -2560 1790 -2560 {lab=swthirteen}
N 1560 -2800 1560 -2560 {lab=swthirteen}
N 2350 -2860 2350 -2640 {lab=swmatrix_bus[4]}
N 2410 -2110 2550 -2110 {lab=swmatrix_bus[1:4]}
N 2410 -2070 2480 -2070 {lab=#net1}
N 2480 -2130 2480 -2070 {lab=#net1}
N 2050 -2070 2110 -2070 {lab=clk_in}
N 2070 -2110 2110 -2110 {lab=en_in}
N 2020 -2070 2050 -2070 {lab=clk_in}
N 2050 -2050 2110 -2050 {lab=vss}
N 2050 -2030 2110 -2030 {lab=vdd}
N 1940 -2090 2110 -2090 {lab=serial_in}
N 2410 -2050 2550 -2050 {lab=swmatrix_bus[6:16]}
N 2410 -2090 2550 -2090 {lab=BUSFIVE}
N 2410 -2030 2530 -2030 {lab=swone}
N 2410 -2010 2540 -2010 {lab=swten}
N 2410 -1990 2550 -1990 {lab=sweleven}
N 2410 -1970 2550 -1970 {lab=swtwo}
N 2410 -1950 2550 -1950 {lab=swtwelve}
N 2410 -1930 2550 -1930 {lab=swthree}
N 2410 -1910 2540 -1910 {lab=swthirteen}
N 2410 -1890 2540 -1890 {lab=swfour}
N 2410 -1870 2540 -1870 {lab=swfourteen}
N 2410 -1850 2540 -1850 {lab=swfive}
N 2410 -1830 2540 -1830 {lab=swfifteen}
N 2410 -1810 2540 -1810 {lab=swsix}
N 2410 -1790 2540 -1790 {lab=swsixteen}
N 2410 -1770 2540 -1770 {lab=swseven}
N 2410 -1750 2540 -1750 {lab=swseventeen}
N 2410 -1730 2540 -1730 {lab=sweighteen}
N 2410 -1710 2540 -1710 {lab=sweight}
N 2410 -1690 2540 -1690 {lab=swnine}
N 50 -3300 120 -3300 {lab=vdd}
N 60 -3040 130 -3040 {lab=vss}
N 240 -3220 280 -3220 {lab=serial_in}
N -110 -3160 -20 -3160 {lab=data}
N 240 -3240 330 -3240 {lab=vdd}
N 240 -3260 340 -3260 {lab=vdd}
N 240 -3200 320 -3200 {lab=vdd}
N 240 -3180 320 -3180 {lab=vss}
N 240 -3160 330 -3160 {lab=#net2}
N 240 -3120 330 -3120 {lab=#net3}
N 240 -3140 340 -3140 {lab=#net4}
N 240 -3100 310 -3100 {lab=#net5}
N 240 -3080 310 -3080 {lab=vss}
N 430 -3460 430 -3400 {lab=en}
N 430 -3340 430 -3300 {lab=VSSd}
N 660 -3600 730 -3600 {lab=vdd}
N 670 -3340 740 -3340 {lab=vss}
N 850 -3520 890 -3520 {lab=en_in}
N 850 -3540 940 -3540 {lab=vdd}
N 850 -3560 950 -3560 {lab=vdd}
N 850 -3500 930 -3500 {lab=vdd}
N 850 -3480 930 -3480 {lab=vss}
N 850 -3460 940 -3460 {lab=#net6}
N 850 -3420 940 -3420 {lab=#net7}
N 850 -3440 950 -3440 {lab=#net8}
N 850 -3400 920 -3400 {lab=#net9}
N 850 -3380 920 -3380 {lab=vss}
N 430 -3460 590 -3460 {lab=en}
N 960 -3990 1040 -3990 {lab=clk}
N 960 -3990 960 -3930 {lab=clk}
N 960 -3870 960 -3820 {lab=VSSd}
N 1200 -4130 1270 -4130 {lab=vdd}
N 1210 -3870 1280 -3870 {lab=vss}
N 1390 -4050 1430 -4050 {lab=clk_in}
N 1040 -3990 1130 -3990 {lab=clk}
N 1390 -4070 1480 -4070 {lab=vdd}
N 1390 -4090 1490 -4090 {lab=vdd}
N 1390 -4030 1470 -4030 {lab=vdd}
N 1390 -4010 1470 -4010 {lab=vss}
N 1390 -3990 1480 -3990 {lab=#net10}
N 1390 -3950 1480 -3950 {lab=#net11}
N 1390 -3970 1490 -3970 {lab=#net12}
N 1390 -3930 1460 -3930 {lab=#net13}
N 1390 -3910 1460 -3910 {lab=vss}
N 160 -400 160 -380 {lab=GND}
N 160 -480 160 -460 {lab=vss}
N 160 -560 160 -540 {lab=#net14}
N 160 -560 280 -560 {lab=#net14}
N 160 -465 280 -465 {lab=vss}
N 340 -465 380 -465 {lab=VSSd}
N 340 -560 375 -560 {lab=VDDd}
N 375 -560 390 -560 {lab=VDDd}
N 380 -465 390 -465 {lab=VSSd}
N 160 -575 160 -560 {lab=#net14}
N 160 -655 160 -635 {lab=vdd}
N 150 -2460 150 -2420 {lab=GND}
N 150 -2560 150 -2520 {lab=top_iref}
N 150 -2700 150 -2625 {lab=top_iref}
N 150 -2700 240 -2700 {lab=top_iref}
N 260 -2700 480 -2700 {lab=top_iref}
N 150 -2630 150 -2560 {lab=top_iref}
N 1570 -3065 1570 -3025 {lab=rvho}
N 1570 -2965 1570 -2945 {lab=vss}
N 1630 -2965 1630 -2945 {lab=vss}
N 1570 -3065 1655 -3065 {lab=rvho}
N 1630 -3025 1695 -3025 {lab=rvlo}
N 2060 -2790 2100 -2790 {lab=vdd}
N 1770 -2840 1770 -2800 {lab=vlo_esd}
N 1810 -2845 1810 -2800 {lab=vho_esd}
N 1930 -3170 1980 -3170 {lab=vho}
N 1930 -3150 1975 -3150 {lab=vho_esd}
N 1930 -3130 1930 -3085 {lab=vss}
N 1930 -3225 1930 -3190 {lab=vdd}
N 1765 -3385 1885 -3385 {lab=vho}
N 1500 -3385 1565 -3385 {lab=rvho}
N 1645 -3305 1710 -3305 {lab=vss}
N 1645 -3465 1720 -3465 {lab=vdd}
N 2350 -3240 2400 -3240 {lab=vlo}
N 2350 -3220 2395 -3220 {lab=vlo_esd}
N 2350 -3200 2350 -3155 {lab=vss}
N 2350 -3295 2350 -3260 {lab=vdd}
N 2185 -3455 2305 -3455 {lab=vlo}
N 1920 -3455 1985 -3455 {lab=rvlo}
N 2065 -3375 2130 -3375 {lab=vss}
N 2065 -3535 2140 -3535 {lab=vdd}
N 1260 -2960 1260 -2890 {lab=vss}
N 1260 -3080 1260 -3020 {lab=vdd}
N 1260 -2980 1330 -2980 {lab=swthirteen}
N 1260 -3000 1350 -3000 {lab=esdoscout}
N 1245 -3215 1290 -3215 {lab=esdoscout}
N 1125 -3135 1195 -3135 {lab=vss}
N 1125 -3295 1220 -3295 {lab=vdd}
N 990 -3215 1045 -3215 {lab=roscout}
C {title.sym} 70 30 0 0 {name=l1 author=", X.J. Lee, Christopher O Amankwaa"}
C {libs/core_analog/Comparator/Nmos_Comparator.sym} 2880 -1340 2 0 {name=xn_comp}
C {libs/core_analog/op_Deadtime_Driver/op_Deadtime_Driver.sym} 1460 -1420 3 1 {name=x1}
C {libs/core_analog/Output_Stage/Output_Stage.sym} 680 -1040 0 1 {name=x2}
C {libs/core_analog/opamp/opamp_p_input.sym} 1880 -1170 0 1 {name=x3}
C {libs/core_analog/opamp/opamp_n_input.sym} 2590 -1260 0 1 {name=x4}
C {libs/core_analog/oscillator/triangle_osc.sym} 1850 -2780 1 0 {name=x5}
C {libs/core_analog/opamp/opamp_p_input.sym} 2210 -2470 1 1 {name=x6}
C {lab_wire.sym} 490 -1320 0 1 {name=p13 sig_type=std_logic lab=push_pull_out}
C {lab_wire.sym} 480 -2700 2 0 {name=p33 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 3000 -2640 0 1 {name=p56 sig_type=std_logic lab=swmatrix_bus[4]}
C {lab_wire.sym} 3000 -2600 0 1 {name=p59 sig_type=std_logic lab=BUSFIVE}
C {lab_wire.sym} 3000 -2680 0 1 {name=p60 sig_type=std_logic lab=swmatrix_bus[3]}
C {lab_wire.sym} 3000 -2720 0 1 {name=p61 sig_type=std_logic lab=swmatrix_bus[2]}
C {lab_wire.sym} 3000 -2760 0 1 {name=p62 sig_type=std_logic lab=swmatrix_bus[1]}
C {lab_wire.sym} 650 -1150 0 0 {name=p47 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1690 -2750 0 0 {name=p64 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1880 -2750 0 1 {name=p65 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1880 -2710 0 1 {name=p66 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 2020 -2440 3 0 {name=p67 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2000 -2440 3 0 {name=p68 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1910 -980 2 0 {name=p70 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1910 -960 2 0 {name=p71 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1910 -1000 0 1 {name=p72 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 2620 -1070 2 0 {name=p73 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2620 -1050 2 0 {name=p74 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2620 -1090 0 1 {name=p75 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 2160 -1280 0 1 {name=p76 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2180 -1470 2 0 {name=p78 sig_type=std_logic lab=top_iref}
C {libs/core_analog/Comparator/Pmos_Comparator.sym} 2200 -1320 2 0 {name=xp_comp1}
C {lab_wire.sym} 2160 -1420 0 0 {name=p80 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2840 -1440 0 0 {name=p82 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2840 -1330 2 1 {name=p83 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2860 -1240 2 1 {name=p85 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 1470 -1600 1 0 {name=p86 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2630 -1330 1 1 {name=p94 sig_type=std_logic lab=swfive}
C {lab_wire.sym} 3040 -1320 1 1 {name=p101 sig_type=std_logic lab=swone
}
C {lab_wire.sym} 650 -950 3 0 {name=p102 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2120 -2730 0 1 {name=p77 sig_type=std_logic lab=bus5_buff}
C {symbols/ppolyf_s.sym} 2120 -2790 0 0 {name=R1
W=4e-6
L=20e-6
model=ppolyf_s
spiceprefix=X
m=1}
C {lab_wire.sym} 2060 -2790 0 1 {name=p79 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3000 -2560 0 1 {name=p81 sig_type=std_logic lab=swmatrix_bus[6]}
C {lab_wire.sym} 3000 -2400 0 1 {name=p84 sig_type=std_logic lab=swmatrix_bus[10]}
C {lab_wire.sym} 3000 -2360 0 1 {name=p105 sig_type=std_logic lab=swmatrix_bus[11]}
C {lab_wire.sym} 3000 -2440 0 1 {name=p106 sig_type=std_logic lab=swmatrix_bus[9]}
C {lab_wire.sym} 3000 -2480 0 1 {name=p107 sig_type=std_logic lab=swmatrix_bus[8]}
C {lab_wire.sym} 3000 -2520 0 1 {name=p108 sig_type=std_logic lab=swmatrix_bus[7]}
C {lab_wire.sym} 3000 -2320 0 1 {name=p109 sig_type=std_logic lab=swmatrix_bus[12]}
C {lab_wire.sym} 3000 -2240 0 1 {name=p110 sig_type=std_logic lab=swmatrix_bus[14]}
C {lab_wire.sym} 3000 -2200 0 1 {name=p111 sig_type=std_logic lab=swmatrix_bus[15]}
C {lab_wire.sym} 3000 -2280 0 1 {name=p112 sig_type=std_logic lab=swmatrix_bus[13]}
C {lab_wire.sym} 3000 -2160 0 1 {name=p113 sig_type=std_logic lab=swmatrix_bus[16]}
C {lab_wire.sym} 2040 -2440 3 0 {name=p119 sig_type=std_logic lab=top_iref}
C {lab_wire.sym} 2940 -1320 1 1 {name=p100 sig_type=std_logic lab=swtwo
}
C {lab_wire.sym} 2740 -1330 1 1 {name=p99 sig_type=std_logic lab=swthree
}
C {lab_wire.sym} 2670 -1330 1 1 {name=p95 sig_type=std_logic lab=swfour
}
C {lab_wire.sym} 2340 -1330 1 1 {name=p93 sig_type=std_logic lab=swsix}
C {lab_wire.sym} 2300 -1330 1 1 {name=p97 sig_type=std_logic lab=swseven}
C {lab_wire.sym} 2260 -1330 1 1 {name=p98 sig_type=std_logic lab=sweight}
C {lab_wire.sym} 2060 -1320 3 0 {name=p91 sig_type=std_logic lab=swnine}
C {lab_wire.sym} 1980 -1320 1 1 {name=p92 sig_type=std_logic lab=swten}
C {lab_wire.sym} 1920 -1320 1 1 {name=p96 sig_type=std_logic lab=sweleven}
C {lab_wire.sym} 1620 -1320 1 1 {name=p45 sig_type=std_logic lab=swtwelve}
C {lab_wire.sym} 1470 -1320 1 1 {name=p87 sig_type=std_logic lab=swfourteen}
C {lab_wire.sym} 1450 -1320 3 0 {name=p88 sig_type=std_logic lab=swfifteen}
C {lab_wire.sym} 1380 -1320 3 0 {name=p89 sig_type=std_logic lab=swsixteen}
C {lab_wire.sym} 1310 -1320 1 1 {name=p90 sig_type=std_logic lab=swseventeen}
C {lab_wire.sym} 1250 -1320 1 1 {name=p103 sig_type=std_logic lab=sweighteen}
C {lab_wire.sym} 1560 -1320 3 0 {name=p104 sig_type=std_logic lab=swthirteen}
C {libs/core_swmatrix/Swmatrix.sym} 2260 -1900 0 0 {name=x7}
C {lab_wire.sym} 2510 -2110 0 1 {name=p133 sig_type=std_logic lab=swmatrix_bus[1:4]}
C {noconn.sym} 2480 -2130 1 0 {name=l16}
C {lab_wire.sym} 1970 -2090 0 1 {name=p135 sig_type=std_logic lab=serial_in
}
C {lab_wire.sym} 2070 -2110 0 1 {name=p136 sig_type=std_logic lab=en_in}
C {lab_wire.sym} 2030 -2070 0 1 {name=p137 sig_type=std_logic lab=clk_in
}
C {lab_wire.sym} 2080 -2050 0 1 {name=p138 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2060 -2030 2 0 {name=p139 sig_type=std_logic lab=vdd}
C {noconn.sym} 3140 -2760 0 1 {name=l24}
C {noconn.sym} 3140 -2720 0 1 {name=l25}
C {noconn.sym} 3140 -2680 0 1 {name=l26}
C {noconn.sym} 3140 -2640 0 1 {name=l27}
C {noconn.sym} 3140 -2600 0 1 {name=l28}
C {noconn.sym} 3140 -2560 0 1 {name=l29}
C {noconn.sym} 3140 -2520 0 1 {name=l30}
C {noconn.sym} 3140 -2480 0 1 {name=l31}
C {noconn.sym} 3140 -2440 0 1 {name=l32}
C {noconn.sym} 3140 -2400 0 1 {name=l33}
C {noconn.sym} 3140 -2360 0 1 {name=l34}
C {noconn.sym} 3140 -2320 0 1 {name=l35}
C {noconn.sym} 3140 -2280 0 1 {name=l36}
C {noconn.sym} 3140 -2240 0 1 {name=l37}
C {noconn.sym} 3140 -2200 0 1 {name=l38}
C {noconn.sym} 3140 -2160 0 1 {name=l39}
C {lab_wire.sym} 2510 -2050 0 1 {name=p69 sig_type=std_logic lab=swmatrix_bus[6:16]}
C {lab_wire.sym} 2520 -2090 0 1 {name=p134 sig_type=std_logic lab=BUSFIVE}
C {lab_wire.sym} 2500 -2030 0 1 {name=p140 sig_type=std_logic lab=swone}
C {lab_wire.sym} 2500 -2010 0 1 {name=p141 sig_type=std_logic lab=swten}
C {lab_wire.sym} 2500 -1990 0 1 {name=p142 sig_type=std_logic lab=sweleven}
C {lab_wire.sym} 2500 -1970 0 1 {name=p143 sig_type=std_logic lab=swtwo}
C {lab_wire.sym} 2500 -1950 0 1 {name=p144 sig_type=std_logic lab=swtwelve}
C {lab_wire.sym} 2500 -1930 0 1 {name=p145 sig_type=std_logic lab=swthree}
C {lab_wire.sym} 2490 -1910 0 1 {name=p146 sig_type=std_logic lab=swthirteen}
C {lab_wire.sym} 2490 -1890 0 1 {name=p147 sig_type=std_logic lab=swfour}
C {lab_wire.sym} 2490 -1870 0 1 {name=p148 sig_type=std_logic lab=swfourteen}
C {lab_wire.sym} 2490 -1850 0 1 {name=p149 sig_type=std_logic lab=swfive}
C {lab_wire.sym} 2490 -1830 0 1 {name=p150 sig_type=std_logic lab=swfifteen}
C {lab_wire.sym} 2490 -1810 0 1 {name=p151 sig_type=std_logic lab=swsix}
C {lab_wire.sym} 2490 -1790 0 1 {name=p152 sig_type=std_logic lab=swsixteen}
C {lab_wire.sym} 2490 -1770 0 1 {name=p153 sig_type=std_logic lab=swseven}
C {lab_wire.sym} 2490 -1750 0 1 {name=p154 sig_type=std_logic lab=swseventeen}
C {lab_wire.sym} 2490 -1730 0 1 {name=p155 sig_type=std_logic lab=sweighteen}
C {lab_wire.sym} 2490 -1710 0 1 {name=p156 sig_type=std_logic lab=sweight}
C {lab_wire.sym} 2490 -1690 0 1 {name=p157 sig_type=std_logic lab=swnine}
C {lab_wire.sym} 110 -3300 0 0 {name=p161 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 130 -3040 0 0 {name=p162 sig_type=std_logic lab=vss}
C {lab_wire.sym} 300 -3200 0 0 {name=p163 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 -3220 0 0 {name=p164 sig_type=std_logic lab=serial_in}
C {lab_wire.sym} -70 -3160 0 0 {name=p165 sig_type=std_logic lab=data}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} -20 -3040 0 0 {name=IO13
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {lab_wire.sym} 300 -3260 0 0 {name=p166 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 310 -3240 0 0 {name=p167 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 280 -3080 0 0 {name=p168 sig_type=std_logic lab=vss}
C {noconn.sym} 330 -3160 2 0 {name=l40}
C {noconn.sym} 340 -3140 2 0 {name=l41}
C {noconn.sym} 320 -3120 2 0 {name=l42}
C {noconn.sym} 300 -3100 2 0 {name=l43}
C {lab_wire.sym} 290 -3180 0 0 {name=p169 sig_type=std_logic lab=vss}
C {vsource.sym} 430 -3370 0 0 {name=V8 value="PULSE(0 3.3 50u 50n 50n 50u 100u 1)" savecurrent=false}
C {lab_wire.sym} 430 -3310 0 1 {name=p32 sig_type=std_logic lab=VSSd}
C {lab_wire.sym} 430 -3420 0 1 {name=p35 sig_type=std_logic lab=en
}
C {lab_wire.sym} 720 -3600 0 0 {name=p36 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 740 -3340 0 0 {name=p38 sig_type=std_logic lab=vss}
C {lab_wire.sym} 910 -3500 0 0 {name=p158 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 890 -3520 0 0 {name=p170 sig_type=std_logic lab=en_in}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 590 -3340 0 0 {name=IO14
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {lab_wire.sym} 910 -3560 0 0 {name=p171 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 920 -3540 0 0 {name=p172 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 890 -3380 0 0 {name=p173 sig_type=std_logic lab=vss}
C {noconn.sym} 940 -3460 2 0 {name=l10}
C {noconn.sym} 950 -3440 2 0 {name=l17}
C {noconn.sym} 930 -3420 2 0 {name=l44}
C {noconn.sym} 910 -3400 2 0 {name=l45}
C {lab_wire.sym} 900 -3480 0 0 {name=p174 sig_type=std_logic lab=vss}
C {lab_wire.sym} 960 -3960 0 1 {name=p34 sig_type=std_logic lab=clk
}
C {vsource.sym} 960 -3900 0 0 {name=V7 value="PULSE(0 3.3 1u 50n 50n 500n 1u 3)" savecurrent=false}
C {lab_wire.sym} 960 -3840 0 1 {name=p42 sig_type=std_logic lab=VSSd}
C {lab_wire.sym} 1260 -4130 0 0 {name=p48 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1280 -3870 0 0 {name=p63 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1450 -4030 0 0 {name=p160 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1430 -4050 0 0 {name=p175 sig_type=std_logic lab=clk_in}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1130 -3870 0 0 {name=IO15
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {lab_wire.sym} 1450 -4090 0 0 {name=p176 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1460 -4070 0 0 {name=p177 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1430 -3910 0 0 {name=p178 sig_type=std_logic lab=vss}
C {noconn.sym} 1480 -3990 2 0 {name=l14}
C {noconn.sym} 1490 -3970 2 0 {name=l15}
C {noconn.sym} 1480 -3950 2 0 {name=l46}
C {noconn.sym} 1460 -3930 2 0 {name=l47}
C {lab_wire.sym} 1430 -4010 0 0 {name=p179 sig_type=std_logic lab=vss}
C {devices/code_shown.sym} -1160 -1650 0 0 {name=Models only_toplevel=false
format="tcleval( @value )"
value="
.include /foss/designs/libs/core_analog/Chipathon2025_pads/xschem/gf180mcu_fd_io.spice
.include /foss/designs/libs/core_analog/Chipathon2025_pads/xschem/gf180mcu_fd_io__asig_5p0_extracted.spice
.include $::180MCU_MODELS/design.ngspice
.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu9t5v0/spice/gf180mcu_fd_sc_mcu9t5v0.spice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice bjt_typical
.lib $::180MCU_MODELS/sm141064.ngspice diode_typical
"}
C {devices/code_shown.sym} -1060 -1960 0 0 {name=Simulation only_toplevel=false value="
.param VDD = 3.3
.global VDDd VSSd
.ic v(swthirteen)=0
.ic v(esdoscout)=0
.ic v(roscout)=0
.ic v(vlo)=.8
.ic v(vho)=2.5
.ic v(vlo_esd)=.8
.ic v(vho_esd)=2.5
.control
save serial_in
save clk_in
save en_in
save VDD
save "x7.x2.xAngel_row_block[1].xSR.xFF[1].out_m"
save "x7.x2.xAngel_row_block[1].xSR.xFF[3].out_m"
save rvho
save vho_esd
save vho
save swone
save swtwo
save swthirteen
save "swmatrix_bus[1]"

TRAN 25n 5u 0

.endc
"}
C {netlist.sym} -1360 -2240 0 0 {name=s1 value="


* data
aclock [ clock_node ] clock_vector
.model clock_vector d_source(input_file=\\"/foss/designs/libs/data_source/data_swmatrix_small.txt\\")
* convert digital signals to analog
aconvert [ clock_node ] [  data ] dac_in
.model dac_in dac_bridge (out_low=0V out_high=3.3V t_rise=50ns t_fall=50ns)
"}
C {vsource.sym} 160 -430 0 0 {name=V2 value=0 savecurrent=false}
C {gnd.sym} 160 -380 0 0 {name=l7 lab=GND}
C {lab_wire.sym} 160 -470 0 0 {name=p19 sig_type=std_logic lab=vss}
C {lab_wire.sym} 160 -655 0 0 {name=p20 sig_type=std_logic lab=vdd}
C {vsource.sym} 310 -560 1 0 {name=V5 value=0 savecurrent=false}
C {vsource.sym} 310 -465 1 0 {name=V6 value=0 savecurrent=false}
C {lab_wire.sym} 390 -465 0 0 {name=p199 sig_type=std_logic lab=VSSd}
C {lab_wire.sym} 390 -560 0 0 {name=p200 sig_type=std_logic lab=VDDd}
C {res.sym} 160 -605 0 0 {name=R2
value=3
footprint=1206
device=resistor
m=1}
C {isource.sym} 150 -2490 2 0 {name=I0 value=10u}
C {gnd.sym} 150 -2420 0 0 {name=l9 lab=GND}
C {vsource.sym} 160 -510 0 0 {name=V1 value=\\\{VDD\\\} savecurrent=false}
C {vsource.sym} 1570 -2995 0 0 {name=V3 value=2.5 savecurrent=false}
C {vsource.sym} 1630 -2995 0 0 {name=V4 value=0.8 savecurrent=false}
C {lab_wire.sym} 1570 -2945 0 0 {name=p23 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1630 -2945 0 0 {name=p24 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1650 -3065 0 0 {name=p25 sig_type=std_logic lab=rvho}
C {lab_wire.sym} 1690 -3025 0 0 {name=p26 sig_type=std_logic lab=rvlo}
C {lab_wire.sym} 1770 -2815 0 0 {name=p1 sig_type=std_logic lab=vlo_esd}
C {lab_wire.sym} 1810 -2825 0 0 {name=p2 sig_type=std_logic lab=vho_esd}
C {libs/core_analog/ESD/io_secondary_5p0.sym} 1780 -3160 0 0 {name=x8}
C {lab_wire.sym} 1970 -3170 0 0 {name=p3 sig_type=std_logic lab=vho}
C {lab_wire.sym} 1970 -3150 0 0 {name=p4 sig_type=std_logic lab=vho_esd}
C {lab_wire.sym} 1930 -3215 0 0 {name=p5 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1930 -3085 0 0 {name=p6 sig_type=std_logic lab=vss}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 1565 -3305 0 0 {name=IO1
model=gf180mcu_fd_io__asig_5p0_extracted
spiceprefix=X
}
C {lab_wire.sym} 1850 -3385 0 0 {name=p7 sig_type=std_logic lab=vho}
C {lab_wire.sym} 1515 -3385 0 0 {name=p8 sig_type=std_logic lab=rvho}
C {lab_wire.sym} 1705 -3465 0 0 {name=p9 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1710 -3305 0 0 {name=p10 sig_type=std_logic lab=vss}
C {libs/core_analog/ESD/io_secondary_5p0.sym} 2200 -3230 0 0 {name=x9}
C {lab_wire.sym} 2390 -3240 0 0 {name=p11 sig_type=std_logic lab=vlo}
C {lab_wire.sym} 2390 -3220 0 0 {name=p12 sig_type=std_logic lab=vlo_esd}
C {lab_wire.sym} 2350 -3285 0 0 {name=p14 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2350 -3155 0 0 {name=p15 sig_type=std_logic lab=vss}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 1985 -3375 0 0 {name=IO2
model=gf180mcu_fd_io__asig_5p0_extracted
spiceprefix=X
}
C {lab_wire.sym} 2270 -3455 0 0 {name=p16 sig_type=std_logic lab=vlo}
C {lab_wire.sym} 1935 -3455 0 0 {name=p17 sig_type=std_logic lab=rvlo}
C {lab_wire.sym} 2125 -3535 0 0 {name=p18 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2130 -3375 0 0 {name=p21 sig_type=std_logic lab=vss}
C {libs/core_analog/ESD/io_secondary_5p0.sym} 1110 -2990 0 0 {name=x10}
C {libs/core_analog/Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 1045 -3135 0 0 {name=IO3
model=gf180mcu_fd_io__asig_5p0_extracted
spiceprefix=X
}
C {lab_wire.sym} 1260 -2905 0 0 {name=p22 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1260 -3055 0 0 {name=p27 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1330 -2980 0 0 {name=p28 sig_type=std_logic lab=swthirteen}
C {lab_wire.sym} 1335 -3000 0 0 {name=p29 sig_type=std_logic lab=esdoscout}
C {lab_wire.sym} 1285 -3215 0 0 {name=p30 sig_type=std_logic lab=esdoscout}
C {lab_wire.sym} 1190 -3135 0 0 {name=p31 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1210 -3295 0 0 {name=p37 sig_type=std_logic lab=vdd}
C {noconn.sym} 990 -3215 2 1 {name=l2}
C {lab_wire.sym} 1035 -3215 0 0 {name=p39 sig_type=std_logic lab=roscout}
