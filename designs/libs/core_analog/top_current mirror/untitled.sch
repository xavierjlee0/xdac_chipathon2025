v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {title.sym} 160 30 0 0 {name=l1 author="Christopher O Amankwaa"}
