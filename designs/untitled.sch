v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_analog/Comparator/Comparator.sym} 50 20 0 0 {name=u1}
